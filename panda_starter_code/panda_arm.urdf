Commit message: Added flicks on joint 7 and changed it back to a 2 point trajectory instead of 3

File: panda_starter_code/panda_arm.urdf (robot description, URDF)
Before this commit: robot panda, 8 links, 7 joints
Links:
- link link7: mass 1.0 -> 1.75
